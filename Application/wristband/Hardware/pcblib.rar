# Altium schematic symbol library PAD.SchLib: 1 symbol
Pins are listed as number, name and electrical type; pins without a type are passive.


## PAD
designator *
pins: 1